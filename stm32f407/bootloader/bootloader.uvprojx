# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: bootloader +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,BOOTLOADER
  c include: ..\inc;..\..\oled_cubemx\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\oled_cubemx\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\oled_cubemx\Drivers\CMSIS\Include;..\..\oled_cubemx\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\oled_cubemx\Inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\bootloader.sct
  group Bootloader
    ./: boot_flash.c boot_fw_info.c boot_main.c boot_proto.c system_stm32f4xx.c gpio.c stm32f4xx_hal_msp.c usart.c stm32f4xx_it.c
    ../../oled_cubemx/Src/: i2c.c
  group Startup
    ./: startup_stm32f407xx.s
  group HAL_Driver
    ../../oled_cubemx/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c

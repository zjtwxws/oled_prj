# Keil uVision project oled_cubemx.uvprojx, settings and files
target oled_cubemx (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: oled_cubemx +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../../stm32f407/inc;..\..\stm32f407\thirdparty\freertos\include;..\..\stm32f407\thirdparty\freertos\portable\GCC\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c i2c.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group UserApp
    ../../stm32f407/src/: debug_console.c display_mgr.c font.c i2c_drv.c iwdg_drv.c key_drv.c led_mgr.c protocol.c ssd1306.c sys_config.c sys_tick.c uart_drv.c user_app.c menu_items.c menu_mgr.c app_fw_info.c ota_req.c freertos_app.c
  group Cli
    ../../stm32f407/src/: cli_cmds.c nr_micro_shell_core.c
  group Freertos
    ../../stm32f407/thirdparty/freertos/portable/GCC/ARM_CM4F/: port.c
    ../../stm32f407/thirdparty/freertos/portable/MemMang/: heap_4.c
    ../../stm32f407/thirdparty/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
target oled_cubemx_slota (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: oled_cubemx +hex
  AfterMake: fromelf.exe --bin --output=@P.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,APP_SLOT_A
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: ..\..\stm32f407\oled_cubemx_slota.sct
target oled_cubemx_slotb (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: oled_cubemx +hex
  AfterMake: fromelf.exe --bin --output=@P.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,APP_SLOT_B
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: ..\..\stm32f407\oled_cubemx_slotb.sct
software components: CMSIS:CORE 4.3.0
